# IAR project stcpu-f4xx-std-v1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG; STM32F40_41xxx; USE_STDPERIPH_DRIVER; FreeRTOS_Kernel; STemWin_GUI; JLINK_RTT_TRACE
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\src\Chip\PeriphDriver\inc; ..\..\src\Chip\STM32F40x\Comm\inc; ..\..\src\Chip\STM32F40x\CMSIS\Device\inc; ..\..\src\Chip\STM32F40x\STM32F4x7_ETH_Driver; ..\..\src\Chip\STM32F40x\STM32F4xx_StdPeriph_Driver\inc; ..\..\src\utlis\inc; ..\..\src\utlis\inc\debug; ..\..\src\utlis\inc\debug\RTT; ..\..\src\3rdPart\Kernel\cfg; ..\..\src\3rdPart\Kernel\inc; ..\..\src\3rdPart\Kernel\ports\IAR; ..\..\src\3rdPart\STemWin\inc; ..\..\src\3rdPart\STemWin\Cfg; ..\..\src\3rdPart\FatFs\inc; ..\..\src\Comm\Core\inc; ..\..\src\Comm\Core\inc\gui; ..\..\src\Comm\Core\inc\system; ..\..\src\Comm\Param\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: FreeRTOS_Kernel
  AARM.AUserIncludes: ..\..\src\3rdPart\Kernel\cfg
  OBJCOPY.OOCOutputFile: stcpu-f4xx-std-v1.bin
  ILINK.IlinkOutputFile: cc.out
  ILINK.IlinkIcfFile: ..\..\src\Chip\STM32F40x\CMSIS\Linker\Chip.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F40_41xxx; USE_STDPERIPH_DRIVER; FreeRTOS_Kernel; STemWin_GUI; UART_TRACE
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\src\Chip\PeriphDriver\inc; ..\..\src\Chip\STM32F40x\Comm\inc; ..\..\src\Chip\STM32F40x\CMSIS\Device\inc; ..\..\src\Chip\STM32F40x\STM32F4x7_ETH_Driver; ..\..\src\Chip\STM32F40x\STM32F4xx_StdPeriph_Driver\inc; ..\..\src\utlis\inc; ..\..\src\utlis\inc\debug; ..\..\src\utlis\inc\debug\RTT; ..\..\src\3rdPart\LwIP\netif; ..\..\src\3rdPart\LwIP\include; ..\..\src\3rdPart\LwIP\netif\ports; ..\..\src\3rdPart\LwIP\include\ipv4; ..\..\src\3rdPart\Kernel\cfg; ..\..\src\3rdPart\Kernel\inc; ..\..\src\3rdPart\Kernel\ports\IAR; ..\..\src\3rdPart\STemWin\inc; ..\..\src\3rdPart\STemWin\Cfg; ..\..\src\Comm\Core\inc; ..\..\src\Comm\Param\inc; ..\..\src\Comm\Protocol\inc; ..\..\src\Comm\Core\inc\list; ..\..\src\Comm\Core\inc\system
  ILINK.IlinkOutputFile: stcpu-cm-v2.out
  group 3rdpart/emWin/cfg
    ../../src/3rdPart/STemWin/Cfg/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
  group 3rdpart/emWin/fonts
    ../../src/3rdPart/STemWin/Fonts/: GUI_FontHZ12.c GUI_FontHZ16.c GUI_FontHZ24.c GUI_FontHZ32.c GUI_UC_EncodeNone.c GUICharPEx.c
  group 3rdpart/emWin/lib
    ../../src/3rdPart/STemWin/Lib/: STemWin532_CM4_OS_IAR.a
  group 3rdpart/emWin/os
    ../../src/3rdPart/STemWin/OS/: GUI_X_OS.c
  group 3rdpart/FatFs/cfg
    ../../src/3rdPart/FatFs/inc/: diskio.h ff.h ffconf.h
  group 3rdpart/FatFs/src
    ../../src/3rdPart/FatFs/src/: diskio.c ff.c
  group 3rdpart/kernel/cfg
    ../../src/3rdPart/Kernel/cfg/: FreeRTOSConfig.h Kernel.c Kernel.h os_app_hook.c
  group 3rdpart/kernel/ports
    ../../src/3rdPart/Kernel/ports/: heap_4.c
    ../../src/3rdPart/Kernel/ports/IAR/: port.c portasm.s portmacro.h
  group 3rdpart/kernel/src
    ../../src/3rdPart/Kernel/src/: croutine.c list.c queue.c tasks.c tasktimers.c
  group app
    ./: appcfg.h AppCore.c main.c main.h stm32f4xx_conf.h
  group chip/periphdriver
    ../../src/Chip/PeriphDriver/src/: Flash.c FlashCfg.c MemMgr.c SRAM.c TFT.c
  group chip/stm32f4xx/cmsis
    ../../src/Chip/STM32F40x/CMSIS/Device/src/: startup_stm32f40_41xxx.s stm32f4xx_it.c system_stm32f4xx_IAR.c
  group chip/stm32f4xx/comm
    ../../src/Chip/STM32F40x/Comm/src/: GPIO.c NVIC.c RTC.c SPI.c StartUpCfg.c TimDly.c UART4.c USART1.c
  group chip/stm32f4xx/ethDriver
    ../../src/Chip/STM32F40x/STM32F4x7_ETH_Driver/: stm32f4x7_eth.c stm32f4x7_eth_conf.h
  group chip/stm32f4xx/StdPeriph_Driver
    ../../src/Chip/STM32F40x/STM32F4xx_StdPeriph_Driver/src/: STM32F4xxStdPeriphLib.a
  group comm/fat
    ../../src/Comm/Core/src/fat/: fatmnt.c
  group comm/gui
    ../../src/Comm/Core/src/gui/: guiMntTask.c guiSkinMnt.c
  group comm/gui/pageDlg
    ../../src/Comm/Core/src/gui/pageDlg/: DemoWinDLG.c
  group comm/msg
    ../../src/Comm/Core/src/msg/: MsgMnt.c
  group comm/param
    ../../src/Comm/Param/src/: Param.c
    ../../src/Comm/Param/inc/: ParamCfg.h
  group comm/utils
    ../../src/utlis/src/: libs.c utils.c
  group comm/utils/debug
    ../../src/utlis/src/debug/: trace.c
  group comm/utils/debug/rtt
    ../../src/utlis/src/debug/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group note
    ../Tools/: iar.txt
    ../Tools/doc/note/: Note.txt
