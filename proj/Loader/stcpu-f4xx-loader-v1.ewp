# IAR project stcpu-f4xx-loader-v1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG; STM32F40_41xxx; USE_STDPERIPH_DRIVER; _LOADER; JLINK_RTT_TRACE
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\src\Chip\PeriphDriver\inc; ..\..\src\Chip\STM32F40x\Comm\inc; ..\..\src\Chip\STM32F40x\CMSIS\Device\inc; ..\..\src\Chip\STM32F40x\STM32F4x7_ETH_Driver; ..\..\src\Chip\STM32F40x\STM32F4xx_StdPeriph_Driver\inc; ..\..\src\3rdPart\LwIP\netif; ..\..\src\3rdPart\LwIP\include; ..\..\src\3rdPart\LwIP\netif\ports; ..\..\src\3rdPart\LwIP\include\ipv4; ..\..\src\utlis\inc; ..\..\src\utlis\inc\debug; ..\..\src\utlis\inc\debug\RTT; ..\..\src\Comm\Param\inc; ..\..\src\Comm\Core\inc\system
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stcpu-f4xx-loader-v1.hex
  ILINK.IlinkOutputFile: cc.out
  ILINK.IlinkIcfFile: ..\..\src\Chip\STM32F40x\CMSIS\Linker\Boot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F40_41xxx; USE_STDPERIPH_DRIVER; _LOADER; JLINK_RTT_TRACE
  group 3rdpart/Lwip/api
    ../../src/3rdPart/LwIP/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group 3rdpart/Lwip/core
    ../../src/3rdPart/LwIP/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group 3rdpart/Lwip/core/ipv4
    ../../src/3rdPart/LwIP/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group 3rdpart/Lwip/netif
    ../../src/3rdPart/LwIP/netif/: etharp.c
  group 3rdpart/Lwip/netif/ports
    ../../src/3rdPart/LwIP/netif/ports/: ethernetif.c lwipopts.h
  group app
    ./: appcfg.h AppCore.c main.c stm32f4xx_conf.h
  group chip/Periphdriver
    ../../src/Chip/PeriphDriver/src/: ETH_EMAC.c Flash.c FlashCfg.c
  group chip/stm32f4xx/cmsis
    ../../src/Chip/STM32F40x/CMSIS/Device/src/: startup_stm32f40_41xxx.s stm32f4xx_it.c system_stm32f4xx_IAR.c
  group chip/stm32f4xx/comm
    ../../src/Chip/STM32F40x/Comm/src/: GPIO.c NVIC.c RTC.c SPI.c StartUpCfg.c STFLASH.c TimDly.c UART4.c USART1.c
  group chip/stm32f4xx/Eth_Driver
    ../../src/Chip/STM32F40x/STM32F4x7_ETH_Driver/: stm32f4x7_eth.c stm32f4x7_eth_conf.h
  group chip/stm32f4xx/StdPeriph_Driver
    ../../src/Chip/STM32F40x/STM32F4xx_StdPeriph_Driver/src/: STM32F4xxStdPeriphLib.a
  group comm/core/iap
    ../../src/Comm/Core/src/iap/: IAP.c
  group comm/core/net
    ../../src/Comm/Core/src/net/: bootnetmnt.c netio.c
  group comm/param
    ../../src/Comm/Param/src/: Param.c
  group comm/utils
    ../../src/utlis/src/: FSMBuffer.c
  group comm/utils/debug
    ../../src/utlis/src/debug/: trace.c
  group comm/utils/debug/rtt
    ../../src/utlis/src/debug/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group comm/utils/libs
    ../../src/utlis/src/: libs.c utils.c
  group note
    ../Tools/: iar.txt
    ../Tools/doc/note/: Note.txt
