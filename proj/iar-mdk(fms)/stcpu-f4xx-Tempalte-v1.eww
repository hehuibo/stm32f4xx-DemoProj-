<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\stcpu-f4xx-Tempalte-v1.ewp</path>
    </project>
    <batchBuild />
</workspace>
