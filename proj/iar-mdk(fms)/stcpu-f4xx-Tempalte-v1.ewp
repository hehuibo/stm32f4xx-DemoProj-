# IAR project stcpu-f4xx-Tempalte-v1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG; STM32F40_41xxx; USE_STDPERIPH_DRIVER; _NoRTOSKernel; JLINK_RTT_TRACE; USE_USB_OTG_FS; USE_EMBEDDED_PHY
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\src\Chip\PeriphDriver\inc; ..\..\src\Chip\STM32F40x\Comm\inc; ..\..\src\Chip\STM32F40x\CMSIS\Device\inc; ..\..\src\Chip\STM32F40x\STM32F4x7_ETH_Driver; ..\..\src\Chip\STM32F40x\STM32F4xx_StdPeriph_Driver\inc; ..\..\src\3rdPart\LwIP\netif; ..\..\src\3rdPart\LwIP\include; ..\..\src\3rdPart\LwIP\netif\ports; ..\..\src\3rdPart\LwIP\include\ipv4; ..\..\src\utlis\inc; ..\..\src\utlis\inc\debug; ..\..\src\utlis\inc\debug\RTT; ..\..\src\Comm\Param\inc; ..\..\src\Comm\Core\inc\system; ..\..\src\3rdPart\FatFs\inc; ..\..\src\Comm\Core\inc\USB; ..\..\src\Chip\STM32F40x\USB-Host-Device_Lib\STM32_USB_OTG_Driver\inc; ..\..\src\Chip\STM32F40x\USB-Host-Device_Lib\STM32_USB_Device_Library\Class\msc\inc; ..\..\src\Chip\STM32F40x\USB-Host-Device_Lib\STM32_USB_Device_Library\Core\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stcpu-f4xx-Tempalte-v1.bin
  postbuild: ..\Tools\soft\BinCipherGen\BinCipherGen Debug\Exe\stcpu-f4xx-Tempalte-v1.bin
  ILINK.IlinkOutputFile: cc.out
  ILINK.IlinkIcfFile: ..\..\src\Chip\STM32F40x\CMSIS\Linker\Chip.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F40_41xxx; USE_STDPERIPH_DRIVER; _NoRTOSKernel; UART_TRACE; USE_USB_OTG_FS; USE_EMBEDDED_PHY
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\src\Chip\PeriphDriver\inc; ..\..\src\Chip\STM32F40x\Comm\inc; ..\..\src\Chip\STM32F40x\CMSIS\Device\inc; ..\..\src\Chip\STM32F40x\STM32F4x7_ETH_Driver; ..\..\src\Chip\STM32F40x\STM32F4xx_StdPeriph_Driver\inc; ..\..\src\3rdPart\LwIP\netif; ..\..\src\3rdPart\LwIP\include; ..\..\src\3rdPart\LwIP\netif\ports; ..\..\src\3rdPart\LwIP\include\ipv4; ..\..\src\3rdPart\FatFs\inc; ..\..\src\utlis\inc; ..\..\src\utlis\inc\debug; ..\..\src\utlis\inc\debug\RTT; ..\..\src\Comm\Param\inc; ..\..\src\Comm\Core\inc\system; ..\..\src\Comm\Core\inc\USB; ..\..\src\Chip\STM32F40x\USB-Host-Device_Lib\STM32_USB_OTG_Driver\inc; ..\..\src\Chip\STM32F40x\USB-Host-Device_Lib\STM32_USB_Device_Library\Class\msc\inc; ..\..\src\Chip\STM32F40x\USB-Host-Device_Lib\STM32_USB_Device_Library\Core\inc
  postbuild: ..\Tools\soft\BinCipherGen\BinCipherGen Release\Exe\stcpu-f4xx-Tempalte-v1.bin
  group 3rdpart/FatFs/cfg
    ../../src/3rdPart/FatFs/inc/: diskio.h ffconf.h
  group 3rdpart/FatFs/src
    ../../src/3rdPart/FatFs/src/: diskio.c ff.c
  group 3rdpart/FatFs/src/opt
    ../../src/3rdPart/FatFs/src/opt/: cc936.c
  group 3rdpart/Lwip/api
    ../../src/3rdPart/LwIP/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group 3rdpart/Lwip/core
    ../../src/3rdPart/LwIP/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group 3rdpart/Lwip/core/ipv4
    ../../src/3rdPart/LwIP/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group 3rdpart/Lwip/netif
    ../../src/3rdPart/LwIP/netif/: etharp.c
  group 3rdpart/Lwip/netif/ports
    ../../src/3rdPart/LwIP/netif/ports/: ethernetif.c lwipopts.h
  group app
    ./: AppCore.c main.c main.h stm32f4xx_conf.h
  group chip/Periphdriver
    ../../src/Chip/PeriphDriver/src/: ETH_EMAC.c Flash.c FlashCfg.c IR.c SDIO.c
  group chip/stm32f4xx/cmsis
    ../../src/Chip/STM32F40x/CMSIS/Device/src/: startup_stm32f40_41xxx.s stm32f4xx_it.c system_stm32f4xx_IAR.c
  group chip/stm32f4xx/comm
    ../../src/Chip/STM32F40x/Comm/src/: GPIO.c NVIC.c PWM.c RTC.c SPI.c StartUpCfg.c STFLASH.c TIM1.c TIM3.c TimDly.c TIMIC.c TSensor.c UART4.c USART1.c
  group chip/stm32f4xx/Eth_Driver
    ../../src/Chip/STM32F40x/STM32F4x7_ETH_Driver/: stm32f4x7_eth.c stm32f4x7_eth_conf.h
  group chip/stm32f4xx/StdPeriph_Driver
    ../../src/Chip/STM32F40x/STM32F4xx_StdPeriph_Driver/src/: STM32F4xxStdPeriphLib.a
  group chip/stm32f4xx/USB-Host-Device_Lib_V2.2.0/USB_Device_Library/class/msc
    ../../src/Chip/STM32F40x/USB-Host-Device_Lib/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group chip/stm32f4xx/USB-Host-Device_Lib_V2.2.0/USB_Device_Library/core
    ../../src/Chip/STM32F40x/USB-Host-Device_Lib/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group chip/stm32f4xx/USB-Host-Device_Lib_V2.2.0/USB_OTG_Driver
    ../../src/Chip/STM32F40x/USB-Host-Device_Lib/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group comm/core/iap
    ../../src/Comm/Core/src/iap/: IAP.c
  group comm/core/net
    ../../src/Comm/Core/src/net/: bootnetmnt.c netio.c
  group comm/core/usbMassStorage
    ../../src/Comm/Core/src/USB/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group comm/param
    ../../src/Comm/Param/src/: Param.c
  group comm/utils/debug
    ../../src/utlis/src/debug/: trace.c
  group comm/utils/debug/rtt
    ../../src/utlis/src/debug/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group comm/utils/libs
    ../../src/utlis/inc/: appcfg.h FSM.h
    ../../src/utlis/src/: FSMBuffer.c libs.c SoftVer.c utils.c
  group note
    ../Tools/: iar.txt
    ../Tools/doc/note/: Note.txt
